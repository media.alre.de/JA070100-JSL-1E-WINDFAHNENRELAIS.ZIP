Properties of the parts of a building model (IFC2X3)

# File
Description: Windfahnenrelais, 2 m/s…9,2 m/s, Hysterese ca. 1 m/s, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: JA070100, Windfahnenrelais, 2 m/s…9,2 m/s, Hysterese ca. 1 m/s, Inneneinstellung
In: Raum
Description: Windfahnen-Relais zur Überwachung von Luftströmungen in Kanälen, in Zu- und Abluftgeräten von Ventilatoren oder elektrischen Heizregistern. Das Windfahnenrelais ist werkseitig auf die minimalen Schaltpunkte eingestellt. Durch Rechtsdrehen der innen liegenden Schraube können die Einschalt-/Abschaltwerte erhöht werden. Einbau erfolgt in senkrechter Paddelstellung von oben in eine waagerechte Rohrleitung/Kanal. Der Einstellbereich beträgt 2 m/s … 9,2 m/s und die Hysterese ca. 1 m/s.; Classification: EC002580 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: JA070100; ModelLabel: JSL-1E; GlobalTradeItemNumber: 4050528047144; ProductURL: https://alre.de/produkt_JA070100
Pset_Specification - NominalLength: 0.13 m; NominalWidth: 0.071 m; NominalDepth: 0.067 m; NetWeight: 0.405
Pset_ALRE_ETIM_Properties - Breite: 71; Höhe: 130; Tiefe: 67; Messprinzip: sonstige; Ausführung des elektrischen Anschlusses: Schraubanschluss; Bemessungsschaltstrom: 15; Anzahl der Schaltpunkte: 1; Einstellbarer Ansprechwert für Strömung bei Gasen: 2; Geeignet für Flüssigkeiten: no; Geeignet für Gase: yes; Mediumtemperatur: -35; Mit Messkopf enthalten: yes; Messkopf im Gerät integriert: yes; Schutzart (IP) Auswerteelektronik: IP65; Schutzart (IP) Messkopf: IP20; Umgebungstemperatur für Auswerteelektronik: -40; Transistorausgang: no; Anzahl der Kontakte als Wechsler: 1; ETIM-Klasse: EC002580; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-JA070100.pdf
